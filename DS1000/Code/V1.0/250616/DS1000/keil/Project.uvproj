# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS80F731x Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0x0000-0x07FF) CLOCK(48000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libary\StdDriver\inc;..\Libary\Device\CMS80F731x\Include;..\USER\Applicantions;..\USER\Ctrl;..\USER\Driver;..\USER\USER;..\USER\Driver\TOUCHLib
  link misc: REMOVEUNUSED
  group CMS
    ../Libary/Device/CMS80F731x/Include/: cms80f731xx.h
    ../Libary/Device/CMS80F731x/: STARTUP_CMS80F731x.A51
  group LIB
    ../Libary/StdDriver/src/: gpio.c system.c timer.c uart.c adc.c buzzer.c crc.c extint.c flash.c i2c.c spi.c lse.c pwm.c wdt.c wut.c led.c
  group Driver
    ../USER/Driver/: Drv_Beep.c Drv_LedDisplay.c Drv_HEAT.c uart0.c Drv_KEY.c Drv_Flash.c Drv_LED.c
  group Applicantions
    ../USER/Applicantions/: SysTick.c Show.c SetVal.c Param.c
  group Ctrl
    ../USER/Ctrl/: Ctrl_Scheduler.c Ctrl_ControlTemp.c Ctrl_DownTime.c
  group USER
    ../USER/USER/: main.c isr.c System_Init.c Structs.c Structs.h include.h
  group Note
    ../USER/Note/: note.txt
  group TOUCHLib
    ../USER/Driver/TOUCHLib/: CheckTouchKey_Set.c REL_Protocol.c CheckTouchKey_Set.h REL_Protocol.h CheckTouchKey_80F73xx.h CheckTouchKey_80F73xx_PT_V1.02.LIB
