# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: CMS80F731x Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0x0000-0x07FF) CLOCK(48000000) MODDP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CORE;..\FWLib\inc;..\SYSTEM;..\USER;..\TOUCHLib
  link misc: REMOVEUNUSED
  group CORE
    ../CORE/: cms80f731xx.h STARTUP_CMS80F731x.A51
  group FWLib
    ../FWLib/src/: uart.c
  group TOUCHLib
    ../TOUCHLib/: CheckTouchKey_Set.h CheckTouchKey_Set.c REL_Protocol.h REL_Protocol.c CheckTouchKey_80F73xx.h CheckTouchKey_80F73xx_PT_V1.02.LIB
  group SYSTEM
    ../SYSTEM/: delay.c time.c uart0.c
  group USER
    ../USER/: isr.c main.c
  group README
    ../: README.txt
