# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS80F731x Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0x0000-0x07FF) CLOCK(48000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\Libary\StdDriver\inc;..\Libary\Device\CMS80F731x\Include
  link misc: REMOVEUNUSED
  group CMS
    ../Libary/Device/CMS80F731x/Include/: cms80f731xx.h
    ../Libary/Device/CMS80F731x/: STARTUP_CMS80F731x.A51
  group LIB
    ../Libary/StdDriver/src/: gpio.c system.c timer.c uart.c adc.c buzzer.c crc.c extint.c flash.c i2c.c spi.c lse.c pwm.c wdt.c wut.c led.c
  group User
    ../code/: isr.c main.c
