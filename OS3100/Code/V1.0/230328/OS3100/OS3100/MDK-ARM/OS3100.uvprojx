# Keil uVision project OS3100.uvprojx, settings and files
target OS3100 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: OS3100 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Core/Inc;                                    ../Drivers/STM32F0xx_HAL_Driver/Inc;                                    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                    ../Drivers/CMSIS/Include;                                    ..\..\USER\Applicantions;                                    ..\..\USER\Ctrl;                                    ..\..\USER\Driver;                                    ..\..\USER\Driver\RTT;                                    ..\..\USER\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Driver
    ../../USER/Driver/: Drv_LedDisplay.c Drv_EC11A.c Drv_Beep.c
  group Applicantions
    ../../USER/Applicantions/: Speed.c PID.c
  group Ctrl
    ../../USER/Ctrl/: Ctrl_Scheduler.c Ctrl_DownTime.c Ctrl_Motor.c
  group USER
    ../../USER/USER/: System_Init.c Structs.c Structs.h include.h
  group Note
    ../../USER/Note/: note.txt
  group RTT
    ../../USER/Driver/RTT/: RTT.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
