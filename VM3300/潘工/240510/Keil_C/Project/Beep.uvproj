# Keil uVision project Beep.uvproj, settings and files
target <Beep> (MCS-51)
  device: SC95F8766 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: Beep +hex
  c flags: Optimize=8
  c define: SC95F8x6x
  c include: ..\FWLib\SC95F_Lib\inc;..\User;..\Bank1\bank1_work.h;..\Bank2\bank2_work.h;..\Bank3\bank3_work.h;..\Code\Applications;..\Code\Ctrl;..\Code\Driver;..\Code\USER
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
    ../Code/USER/: System_Init.c Structs.c Structs.h include.h
  group Drivers
    ../Drivers/SCDriver_NixieTube/C/: SCDriver_NixieTube.c
    ../Drivers/TKDriver/C/: SC95F8X6X_HighSensitive_lib_T1_L_V2.1.0.LIB TKDriver.C
  group FWLib
    ../FWLib/SC95F_Lib/src/: sc95f_timer1.c sc95f_timer3.c sc95f_pwm.c sc95f_timer0.c sc95f_gpio.c sc95f_option.c
  group Startup
    ./: STARTUP.A51 L51_BANK.A51
  group Applications
    ../Code/Applications/: Show.c Speed.c PID.c SysTick.c
  group Ctrl
    ../Code/Ctrl/: Ctrl_Scheduler.c Ctrl_Motor.c
  group Driver
    ../Code/Driver/: Drv_Beep.c Drv_Touch.c Drv_WS2812.c Drv_Motor.c Drv_Infrared.c
  group Note
    ../Code/Note/: note.txt
