# Keil uVision project HHMS4100.uvprojx, settings and files
target HHMS4100 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HHMS4100 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/Portable/RVDS/ARM_CM3;../FreeRTOS;../FreeRTOS/Include;../USER/Applications;../USER/Ctrl;../USER/Driver;../USER/USER;../SystemView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Protable
    ../FreeRTOS/Portable/MemMang/: heap_4.c
    ../FreeRTOS/Portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/Source
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Driver
    ../USER/Driver/: Drv_Beep.c Drv_HT16H25.c Drv_IIC.c Drv_EC11A.c Drv_PT1000.c Drv_Motor.c Drv_Flash.c Drv_HEAT.c
  group Applications
    ../USER/Applications/: SysTick.c Show.c LCDFont.h LCDFont.c Param.c Speed.c SetVal.c PID.c Calibration.c
  group Ctrl
    ../USER/Ctrl/: Ctrl_Scheduler.c Ctrl_Motor.c Ctrl_DownTime.c Ctrl_ControlTemp.c
  group USER
    ../USER/USER/: System_Init.c Structs.c Structs.h include.h
  group SystemView
    ../SystemView/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c RTT.c
  group Note
    ../USER/Note/: note.txt
software components: CMSIS:CORE 4.3.0
